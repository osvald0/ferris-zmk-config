## boards/sparkfun_pro_micro_rp2040.conf
```kconfig
CONFIG_ZMK_BLE=n
CONFIG_ZMK_SPLIT=y
CONFIG_ZMK_SPLIT_BLE=n
CONFIG_ZMK_SPLIT_WIRED=y
CONFIG_UART_INTERRUPT_DRIVEN=y
```
